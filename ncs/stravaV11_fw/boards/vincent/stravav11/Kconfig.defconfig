## ncs/stravaV11_fw/boards/vincent/stravav11/board.yml
```yaml
board:
  name: stravav11
  full_name: stravaV11 custom PCB
  vendor: vincent
  socs:
  - name: nrf52840
```
